# IAR project DS203SYS.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: ..\..\FWLib\inc; ..\..\USBLib\inc; ..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: DS203SYS.hex
  ILINK.IlinkOutputFile: DS203SYS.out
  ILINK.IlinkIcfFile: E:\DS0203\SYS_V1.34\IAR_V5_Prpject\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCOptStrategy: 0
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../FWLib/src/: stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c
  group Program
    ../source/: ASM.s BIOS.c Config.c Function.c Ident.c Interrupt.c LCD.c Main.c Memory.c scsi_data.c SPI_flash.c USB_bot.c USB_desc.c USB_endp.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group USBLib
    ../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
