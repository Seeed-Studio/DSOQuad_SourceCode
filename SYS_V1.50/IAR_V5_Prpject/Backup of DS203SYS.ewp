# IAR project Backup of DS203SYS.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: STM32F10x ST STM32F10x
  ICCARM.CCIncludePath2: ..\..\FWLib\inc; ..\..\USBLib\inc; ..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../FWLib/src/: stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c
  group Program
    ../source/: ASM.s BIOS.c Config.c Ext_Flash.c FAT12.c Function.c Ident.c Interrupt.c LCD.c Main.c Memory.c scsi_data.c USB_bot.c USB_desc.c USB_endp.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group USBLib
    ../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
