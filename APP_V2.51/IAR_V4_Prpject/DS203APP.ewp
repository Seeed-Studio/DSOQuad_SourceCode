# IAR project DS203APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10x ST STM32F10x
  ICCARM.CCIncludePath2: ..\..\FWLib\inc; ..\..\USBLib\inc; ..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../FWLib/src/: stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c
  group Program
    ../source/: BIOS.s Calibrat.c Draw.c Files.c Function.c Ident.c Interrupt.c Main.c Menu.c Process.c
